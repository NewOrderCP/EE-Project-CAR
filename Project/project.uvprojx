# Keil uVision project project.uvprojx, settings and files
target GPIO (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;D:\keil\ARM\ARMCC\include;D:\keil\ARM\RV31\LIB\ST\STM32F10x_StdPeriph_Driver\inc;..\HARDWARE\CCD_ADC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\PID;..\HARDWARE\EXTI;..\STM32F10x_StdPeriph_Driver\inc;..\User;..\HARDWARE\INF;..\HARDWARE\STEER;..\HARDWARE\WAVES;..\User\eMPL;..\HARDWARE\ADC;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\LDC1314;..\HARDWARE\Filter;..\HARDWARE\I2C;..\HARDWARE\CRC8;..\HARDWARE\KEY;..\HARDWARE\HC05;..\HARDWARE\USART2;..\HARDWARE\HMC;..\HARDWARE\hc04
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c delay.c motor.c math.h Usart.c
  group StdPeriph_Driver
    ../User/: stm32f10x_it.c system_stm32f10x.c
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group Startup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group HARDWARD
    ../HARDWARE/PID/: PID.C
    ../HARDWARE/INF/: inf.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: OLED_I2C.c
    ../HARDWARE/Filter/: Fileter.c
    ../HARDWARE/CRC8/: crc8.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/HC05/: hc05.c
    ../User/: MPU6050.c mpuiic.c oycq_delay.c
    ../User/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/hc04/: hc04.c
    ../HARDWARE/TIMER/: timer.c
